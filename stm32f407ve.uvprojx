# Keil uVision project stm32f407ve.uvprojx, settings and files
target firm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407ve +hex
  BeforeMake: python.exe ./scripts/semver.py
  BeforeMake: ceedling.bat test:all
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c include: .\src\cmsis;.\lib\cmsis\Include;.\lib\cmsis\Device\ST\STM32F4xx\Include;.\lib\STM32F4xx_StdPeriph_Driver\inc;.\src;.\src\drivers;.\src\timers;.\src\queue;.\src\protocol;.\src\version
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start_up
    ./src/cmsis/: system_stm32f4xx.c
    ./keil/: startup_stm32f40xx.s
  group firm
    ./src/: main.c stm32f4xx_it.c uart_queue_manager.c crc.c
  group lib/std/src
    ./lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c
  group drivers
    ./src/drivers/: inout.c uart.c tim6.c
  group timers
    ./src/timers/: delay.c timers.c
  group queue
    ./src/queue/: ring_queue.c
  group protocol
    ./src/protocol/: packet_parser.c reciever.c command_parser.c
  group version
    ./src/version/: version.c
